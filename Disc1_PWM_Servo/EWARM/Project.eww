<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Disc1_PWM_Servo.ewp</path>
  </project>
  <batchBuild />
</workspace>
